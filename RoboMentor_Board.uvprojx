# Keil uVision project RoboMentor_Board.uvprojx, settings and files
target Framework (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RoboMentor_Board
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,USE_STM324x9I_EVAL,USE_USB_OTG_FS,USE_ULPI_PHY
  c include: .\Framework\Core;.\Framework\Conf;.\Framework\Driver\inc;.\Framework\Api\inc;.\Framework\Service\inc;.\Framework\Start\inc;.\Framework\Service\USB_Driver\inc;.\Framework\Service\USB_Library\Core\inc;.\Framework\Service\USB_Library\Class\cdc\inc;.\Framework\Service\FreeRTOS\include;.\Framework\Test_code;.\Framework\Cjson;.\Framework\RoboMentor\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Framework/Start/src/: main.c start_task.c user_code.c stm32fxxx_it.c user_instruction.c IRQHandler.c
  group Core
    ./Framework/Core/: system_stm32f4xx.c startup_stm32f427_437xx.s
  group RoboMentor_Lib
    ./Framework/Lib/: RoboMentor_Board.lib
